# Keil uVision project GPIO.uvproj, settings and files
target OLED (MCS-51)
  device: N76E003 Nuvoton
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x47FF)  XRAM(0 - 0x2FF) CLOCK(16000000)
  output: OLED +hex
  c flags: Optimize=9 SizeSpeed=1
  c define: FOSC_160000
  c include: .\Include;.\OLED
  group Source Group 1
    ./: MAIN.C
  group Common
    ./Common/: Common.c Delay.c
  group Startup
    ./Startup/: STARTUP.A51
  group OLED
    ./OLED/: oled.c
